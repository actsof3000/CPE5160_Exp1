# Keil uVision project Experiment1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Experiment1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Exp_1_Fall_2018/: AT89C51RC2.h Main.h memory_test.c memory_test.h PORT.H print_bytes.c print_bytes.h
    ./: main.c UART.h UART.c Util.h LCD.h LCD.c
